Commit message: Update 09-simple_cube.urdf

File: urdf/00_BasicSamples/09-simple_cube.urdf (robot description, URDF)
Before this commit: robot simple_cube_robot, 1 links, 0 joints
Links:
- link base_link: geometry visual mesh filename=../12345/00_BasicSamples/simple_cube.dae
